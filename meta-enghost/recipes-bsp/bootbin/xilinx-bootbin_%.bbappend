# No bitstream in the boot.bin, thank you :)
BIF_BITSTREAM_ATTR = ""

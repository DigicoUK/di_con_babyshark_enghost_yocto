
# FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

EXTRA_OEMAKE:append := " --no-silent"